# Keil uVision project application.uvprojx, settings and files
target application (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: BAT32G157GK64FB Cmsemicon
  pack: Cmsemicon.BAT32G157.1.00.4
  cpu: IRAM(0x20000000,0x08000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: application +hex
  AfterMake: fromelf --bin -o "$L@L" "#L"
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: ..\Driver\inc;..\Usb_Lib\src\apl_config;..\Usb_Lib\src\fmc;..\Usb_Lib\src\inc;..\Usb_Lib\src\byteq;..\Usb_Lib\src\driver\inc;..\Usb_Lib\src\hw\inc;..\User\App;..\User\Drv;..\User\Hal
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Library
    ../Driver/src/: clk.c
  group Usb_phid
    ../Usb_Lib/src/apl_config/phid/: usb_phid_driver.c
  group Usb_driver
    ../Usb_Lib/src/driver/: usb_cdataio.c usb_clibusbip.c usb_hbc.c usb_hdriver.c usb_hdriverapi.c usb_hlibusbip.c usb_hscheduler.c usb_hsignal.c usb_hstdfunction.c usb_pbc.c usb_pcontrolrw.c usb_pdriver.c usb_pintfifo.c usb_pinthandler_usbip0.c usb_plibusbip.c usb_psignal.c usb_pstdfunction.c usb_pstdrequest.c usb_usbif_api.c
  group Usb_hw
    ../Usb_Lib/src/hw/: usb_157_mcu.c usb_creg_abs.c usb_creg_access.c usb_dma.c usb_hreg_abs.c usb_hreg_access.c usb_preg_abs.c usb_preg_access.c
  group User_app
    ../User/App/: main.c usb_phid_descriptor.c usb_phid_keyboard_apl.c
  group User_drv
    ../User/Drv/: drv_timer.c
  group User_hal
    ../User/Hal/: hardware.c interrupt.c
software components: CMSIS:CORE 5.6.0, Device:Startup 1.0.0
